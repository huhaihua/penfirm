# Keil uVision project pen.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: pen
  c flags: Optim=1
  c include: .\Demo\CORTEX_STM32F103_Keil\STM32Lib;.\Source\include;.\Demo\CORTEX_STM32F103_Keil;.\Demo\CORTEX_STM32F103_Keil\adc;.\Demo\CORTEX_STM32F103_Keil\DRV8830;.\Demo\CORTEX_STM32F103_Keil\Encode;.\Demo\CORTEX_STM32F103_Keil\ParTest;.\Demo\CORTEX_STM32F103_Keil\pwm;.\Source\portable\Keil;.\Source\portable\RVDS\ARM_CM3;.\Demo\Common\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./Demo/CORTEX_STM32F103_Keil/STM32Lib/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
    ./Demo/CORTEX_STM32F103_Keil/: STM32F10x.s
  group Demo
    ./Demo/CORTEX_STM32F103_Keil/: main.c
    ./Demo/CORTEX_STM32F103_Keil/serial/: serial.c
    ./Demo/CORTEX_STM32F103_Keil/pwm/: pwm.c
    ./Demo/CORTEX_STM32F103_Keil/ParTest/: ParTest.c
    ./Demo/CORTEX_STM32F103_Keil/Encode/: encode.c
    ./Demo/CORTEX_STM32F103_Keil/DRV8830/: DRV8830.c
    ./Demo/CORTEX_STM32F103_Keil/adc/: adc.c
  group freeRtos
    ./Source/: list.c queue.c tasks.c event_groups.c
    ./Source/portable/RVDS/ARM_CM3/: port.c
    ./Source/portable/MemMang/: heap_2.c
